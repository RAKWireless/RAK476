# Keil uVision project RAK473.uvprojx, settings and files
target RAK473 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RAK439
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\..\..\..\platform\ST\CMSIS\CM3\CoreSupport;..\..\..\..\platform\ST\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\platform\bsp;..\..\..\..\common\mem;..\..\..\..\uart_wifi_drv;..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group examples_nos/ap_sta
    ../../src/: apsta_test.c tcp_udp.c ap_sta.c
  group platform_stm32f10x/bsp
    ../../../../platform/bsp/: bsp.c bsp.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
    ../../../../platform/bsp/arm/: startup_stm32f10x_md.s
  group platform_stm32f10x/libraries
    ../../../../platform/ST/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group uart_wifi_drv
    ../../../../uart_wifi_drv/: rak_config_init.c utils.c rak473_driver.c
