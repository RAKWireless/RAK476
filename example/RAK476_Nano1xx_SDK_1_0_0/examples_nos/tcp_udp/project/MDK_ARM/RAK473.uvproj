# Keil uVision project RAK473.uvproj, settings and files
target RAK473 (5060020::V5.06 (build 20)::ARMCC)
  device: NANO100LE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: RAK439
  c flags: Optim=4 OneElfS=1
  c misc: --C99 --gnu
  c include: ..\..\..\..\platform\nano100\libraries\CMSIS\Include;..\..\..\..\platform\nano100\libraries\Device\Nuvoton\NANO1xx\Include;..\..\..\..\platform\nano100\libraries\NANO1xx_Drivers\Include;..\..\..\..\platform\nano100\bsp;..\..\..\..\uart_wifi_drv;..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group examples_nos/ap_sta
    ../../src/: apsta_test.c tcp_udp.c ap_sta.c
  group platform_nano100/bsp
    ../../../../platform/nano100/bsp/: bsp.c
  group platform_nano100/libraries
    ../../../../platform/nano100/libraries/NANO1xx_Drivers/Source/: nano1xx_fmc.c nano1xx_gpio.c nano1xx_pdma.c nano1xx_spi.c nano1xx_sys.c nano1xx_timer.c nano1xx_uart.c
    ../../../../platform/nano100/libraries/Device/Nuvoton/NANO1xx/Source/ARM/: startup_nano1xx.s
    ../../../../platform/nano100/libraries/Device/Nuvoton/NANO1xx/Source/: system_nano1xx.c
  group uart_wifi_drv
    ../../../../uart_wifi_drv/: rak473_driver.c rak_config_init.c utils.c
